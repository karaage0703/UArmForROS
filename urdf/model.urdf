Commit message: Bug fix

File: urdf/model.urdf (robot description, URDF)
Before this commit: robot firefighter, 11 links, 10 joints
Links:
- link base: geometry visual box size=0.09 0.14 0.04
